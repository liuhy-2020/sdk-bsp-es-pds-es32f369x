# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: ES32F3696LT Eastsoft ES32F3696LT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ES32F36xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; libraries\CMSIS\Include; drivers; libraries\ES32F36xx_ALD_StdPeriph_Driver\Include; .; applications; ..\..\..\components\libc\compilers\common; ..\..\..\include; ..\..\..\components\drivers\include; libraries\CMSIS\Device\EastSoft\ES32F36xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group Libraries
    libraries/ES32F36xx_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dac.c ald_dma.c ald_ebi.c ald_flash.c ald_flash_ext.c ald_gpio.c ald_i2c.c ald_i2s.c ald_iap.c ald_nand.c ald_nor_lcd.c ald_pis.c ald_pmu.c ald_qspi.c ald_rmu.c ald_rtc.c ald_rtchw.c ald_spi.c ald_sram.c ald_timer.c ald_trng.c ald_tsense.c ald_uart.c ald_usb.c ald_wdt.c utils.c
    libraries/CMSIS/Device/EastSoft/ES32F36xx/Startup/iar/: startup_es32f36xx.s
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
